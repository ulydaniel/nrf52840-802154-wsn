## boards/Ozturk/OzturkLab/board.yml
```yaml
board:
  name: OzturkLab
  full_name: OzturkLab
  vendor: Ozturk
  socs:
    - name: nrf52840
```
